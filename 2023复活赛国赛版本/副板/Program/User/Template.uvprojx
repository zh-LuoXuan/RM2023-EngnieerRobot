# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: zero
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c misc: --c99
  c include: ..\User;..\System\include;..\System\Core;..\System\CMSIS;..\System\FWLib\inc;..\System\FreeRTOS\include;..\System\FreeRTOS\CMSIS_RTOS;..\System\FreeRTOS\portable\RVDS\ARM_CM4F;..\Drivers\RC;..\Drivers\CAN;..\Drivers\PWM;..\Drivers\USART;..\Drivers\GPIO;..\Drivers\TIM;..\Devices\CAN;..\Devices\RemoteControl;..\Drivers\IWDG;..\Task\Start;..\Task\Detect;..\Task\Control;..\Task\Fine_Tuning;..\Task\Motor_Control;..\Algorithm;..\Algorithm\PID;..\Algorithm\User_Lib;..\Algorithm\Kalman;..\Algorithm\Encoder_Process;..\MPU;..\Judgement
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c
  group Task
    ../Task/Detect/: detect_task.c
    ../Task/Start/: start_task.c
    ../Task/Control/: control_task.c
    ../Task/Fine_Tuning/: fine_tuning_task.c
    ../Task/Motor_Control/: motor_control_task.c
  group Devices
    ../Devices/RemoteControl/: RemoteControl.c
    ../Devices/CAN/: CAN_receive.c
  group Drivers
    ../Drivers/RC/: rc.c
    ../Drivers/CAN/: can.c
    ../Drivers/GPIO/: gpio.c
    ../Drivers/TIM/: Time7.c
    ../Drivers/IWDG/: iwdg.c
    ../Drivers/USART/: usart6.c Usart1.c
  group Algorithm
    ../Algorithm/PID/: pid.c new_pid.c
    ../Algorithm/User_Lib/: user_lib.c
    ../Algorithm/Kalman/: kalman.c kalman_filter.c
    ../MPU/: arm_cortexM4lf_math.lib
    ../Algorithm/Encoder_Process/: Encoder_process.c
  group MPU
    ../MPU/: accelerometer_calibration.c BSP_Flash.c BSP_MPU9250_Init.c Filter_Control.c IMUTask.c mpu_delay.c MPU_SPI_Init.c MPU_TIME_Init.c
  group System/include
    ../System/include/: sys.c delay.c
  group System/Core
    ../System/Core/: startup_stm32f40_41xxx.s
  group System/CMSIS
    ../System/CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group System/FWLib
    ../System/FWLib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group System/FreeRTOS_Core
    ../System/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../System/FreeRTOS/CMSIS_RTOS/: cmsis_os.c
  group System/FreeRTOS_Portable
    ../System/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../System/FreeRTOS/portable/MemMang/: heap_4.c
  group Judgement
    ../Judgement/: Judge_Task.c judgement_info.c protocol.c RM_Client_UI.c
  group README
    ../README/: Readme.txt
